# Keil uVision project samrt_traffic_light_system.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: samrt_traffic_light_system +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./smart_traffic/: display.c main.c traffic_light.c config.h display.h traffic_light.h timer.c timer.h
